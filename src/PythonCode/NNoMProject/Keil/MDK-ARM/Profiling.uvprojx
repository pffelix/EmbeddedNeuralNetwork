# Keil uVision project Profiling.uvprojx, settings and files
target Profiling (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Profiling +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx, ARM_MATH_CM4, __FPU_PRESENT=1, ARM_MATH_DSP, ARM_MATH_LOOPUNROLL
  c include: ../Inc;../Src/include;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;.\nnom-master\inc;.\nnom-master\port;./
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c CycleCounter.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group NNoM
    ./nnom-master/src/backends/: nnom_local.c
    ./nnom-master/src/core/: nnom.c nnom_layers.c nnom_tensor.c nnom_utils.c
    ./nnom-master/src/layers/: nnom_activation.c nnom_avgpool.c nnom_baselayer.c nnom_concat.c nnom_conv2d.c nnom_cropping.c nnom_dense.c nnom_dw_conv2d.c nnom_flatten.c nnom_global_pool.c nnom_input.c nnom_lambda.c nnom_matrix.c nnom_maxpool.c nnom_output.c nnom_rnn.c nnom_softmax.c nnom_sumpool.c nnom_upsample.c nnom_zero_padding.c
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, CMSIS:NN Lib 1.2.0, Device:Startup 1.3.1
